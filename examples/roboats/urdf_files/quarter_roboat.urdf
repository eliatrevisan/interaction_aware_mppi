Commit message: optimized dynamics and objective

File: examples/roboats/urdf_files/quarter_roboat.urdf (robot description, URDF)
Before this commit: robot roboat, 2 links, 1 joints
Links:
- link front_ball: mass None -> 1.0; geometry visual sphere radius=0.05
